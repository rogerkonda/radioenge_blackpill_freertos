<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\hellobluepillSTM32F411CEUx.ewp</path>
  </project>
  <batchBuild />
</workspace>
